# Keil uVision project prj_quadrotor.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: prj_quadrotor
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Source\Common\Inc;.\Source\Inputs\Inc;.\Source\Sensors\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group STM32CubeMX:Peripheral Sources
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Src/: gpio.c i2c.c dma.c usart.c
  group Inputs
    ./Source/Inputs/Src/: digital_input.c analog_input.c com_input.c
  group Sensors
    ./Source/Sensors/Src/: adxl345.c itg3205.c hmc5883l.c imu.c
  group Common
    ./Source/Common/Inc/: defines.h
    ./Source/Common/Src/: calc.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:Startup 2.6.3
